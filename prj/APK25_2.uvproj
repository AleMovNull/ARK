# Keil uVision project APK25_2.uvproj, settings and files
target APK25_2 (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1") ESEL
  output: APK25_2 +hex
  c flags: Optim=1 wLevel=2
  c include: ..\inc_std_lib_periph;..\inc_system;..\inc_user;..\src_std_lib_periph;..\src_system;..\src_user
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System
    ../src_system/: system_MDR1986VE1T.c startup_MDR1986VE1T.s MDR1986VE1T_it.c
  group Std_Lib_Periph
    ../src_std_lib_periph/: MDR32F9Qx_bkp.c MDR32F9Qx_ebc.c MDR32F9Qx_eeprom.c MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_uart.c MDR32F9Qx_adc.c MDR32F9Qx_arinc429r.c MDR32F9Qx_arinc429t.c
  group User
    ../src_user/: Main.c Init_APK25.c APK25_Angle.c APK25_QBUS.c APK25_Chassis.c APK25_Debug.c APK25_SF.c APK25_Filtr.c APK25_FC.c APK25_TransRec.c APK25_Modes.c
